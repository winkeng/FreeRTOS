# Keil uVision project Winken.uvprojx, settings and files
target FreeRTOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\FreeRTOS\portable\MemMang;..\HARDWARE\LED;..\SYSTEM\sys;..\HARDWARE;..\HARDWARE\KEY
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/: timer.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
